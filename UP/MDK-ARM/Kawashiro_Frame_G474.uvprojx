# Keil uVision project Kawashiro_Frame_G474.uvprojx, settings and files
target Kawashiro_Frame_G474 (6240000::V6.24::ARMCLANG)
  device: STM32G474VETx STMicroelectronics
  pack: Keil.STM32G4xx_DFP.2.2.0
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: Kawashiro_Frame_G474 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32G474xx,ARM_MATH_CM4,ARM_MATH_CM4,__FPU_USED=1U,__FPU_PRESENT=1U
  c include: ../Core/Inc;../Drivers/STM32G4xx_HAL_Driver/Inc;../Drivers/STM32G4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32G4xx/Include;../Drivers/CMSIS/Include;../USB_Device/App;../USB_Device/Target;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc;../Project/Algorithm_Drivers;../Project/BSP;../Project/Commnuicate_Drivers;../Project/Hardware_Drivers;../Project/Robot_Application;../Project/UI
  asm include: ../Core/Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Application/User/Core
    ../Core/Src/: main.c gpio.c app_freertos.c adc.c crc.c dac.c dma.c fdcan.c i2c.c opamp.c spi.c tim.c usart.c stm32g4xx_it.c stm32g4xx_hal_msp.c stm32g4xx_hal_timebase_tim.c
  group Robot_Application
    ../Project/Robot_Application/: RoboControl.c Chassis.c Communicate.c Gimbal.c INS.c Shoot.c Aim.c Key_LED.c ErrorHandle.c Define.h
  group Commnuicate_Drivers
    ../Project/Commnuicate_Drivers/: CAN_Driver.c USART_Driver.c USB_Driver.c
  group Hardware_Drivers
    ../Project/Hardware_Drivers/: Referee_Unpack.c Remote_Control.c SuperCap_Driver.c Motor_Driver.c Motor_DJI_Driver.c Motor_DAMIAO_Driver.c Motor_Unitree_Driver.c Motor_DrEmpower.c
  group Algorithm_Drivers
    ../Project/Algorithm_Drivers/: controller.c CRC8_CRC16.c Function.c kalman_filter.c PID.c Power_Limit.c QuaternionEKF.c user_lib.c Vofa.c Motor_Compensation.c Motor_Compensation_Data.c
  group BSP
    ../Project/BSP/: BMI088driver.c BMI088Middleware.c Buzzer.c DWT.c PWM.c Key.c LED.c Flash.c
  group UI
    ../Project/UI/: UI_Task.c ui_interface.c ui_default_Dynamic_0.c ui_default_Dynamic_1.c ui_default_Dynamic_2.c ui_default_Static_0.c ui_default_Static_1.c ui_default_Static_2.c ui_default_Static_3.c ui_default_Static_4.c ui_default_Static_5.c ui_default_Static_6.c ui_default_Static_7.c ui_default_Static_8.c ui_default_Static_9.c ui_default_Static_10.c ui_default_Static_11.c ui_default_Static_12.c ui_default_Static_13.c ui_default_Static_14.c
  group Application/MDK-ARM
    ./: startup_stm32g474xx.s
  group Drivers/STM32G4xx_HAL_Driver
    ../Drivers/STM32G4xx_HAL_Driver/Src/: stm32g4xx_hal_pcd.c stm32g4xx_hal_pcd_ex.c stm32g4xx_ll_usb.c stm32g4xx_hal.c stm32g4xx_hal_rcc.c stm32g4xx_hal_rcc_ex.c stm32g4xx_hal_flash.c stm32g4xx_hal_flash_ex.c stm32g4xx_hal_flash_ramfunc.c stm32g4xx_hal_gpio.c stm32g4xx_hal_exti.c stm32g4xx_hal_dma.c stm32g4xx_hal_dma_ex.c stm32g4xx_hal_pwr.c stm32g4xx_hal_pwr_ex.c stm32g4xx_hal_cortex.c stm32g4xx_hal_adc.c stm32g4xx_hal_adc_ex.c stm32g4xx_ll_adc.c stm32g4xx_hal_crc.c stm32g4xx_hal_crc_ex.c stm32g4xx_hal_dac.c stm32g4xx_hal_dac_ex.c stm32g4xx_hal_fdcan.c stm32g4xx_hal_i2c.c stm32g4xx_hal_i2c_ex.c stm32g4xx_hal_opamp.c stm32g4xx_hal_opamp_ex.c stm32g4xx_hal_spi.c stm32g4xx_hal_spi_ex.c stm32g4xx_hal_tim.c stm32g4xx_hal_tim_ex.c stm32g4xx_hal_uart.c stm32g4xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32g4xx.c
  group Application/User/USB_Device/Target
    ../USB_Device/Target/: usbd_conf.c
  group Application/User/USB_Device/App
    ../USB_Device/App/: usb_device.c usbd_desc.c usbd_cdc_if.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Middlewares/USB_Device_Library
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
software components: CMSIS:CORE 6.1.0, CMSIS:DSP 1.16.2
